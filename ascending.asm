MOV R3, #4
MOV R4, #4
MOV DPTR, #4500H
REPT1: MOV R5, DPL
MOV R6, DPH
MOVX A, @ DPTR
MOV B, A
RPT: INC DPTR
MOVX A, @ DPTR
MOV R0, A
CLR C
SUBB A, B
JNC CHKNXT
EXCH: PUSH DPL
PUSH DPH
MOV DPL, R5
MOV DPH, R6
MOV A, R0
MOVX @ DPTR, A
POP DPH
POP DPL
MOV A, B
MOVX @ DPTR, A
MOV B, R0
CHKNXT: DJNZ R3, RPT
DEC R4
MOV A, R4
MOV R3, A
INC R4
MOV DPL, R5
MOV DPH, R6
INC DPTR
DJNZ R4, REPT1
END